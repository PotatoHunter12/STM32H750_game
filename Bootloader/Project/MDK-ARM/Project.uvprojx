# Keil uVision project Project.uvprojx, settings and files
target STM32H750B_DISCO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H745I_DISCO +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../../Source;../../..\ThirdParty\STM32Cube_FW_H7\Drivers/CMSIS/Include;../../..\ThirdParty\STM32Cube_FW_H7\Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../..\ThirdParty\STM32Cube_FW_H7\Drivers/STM32H7xx_HAL_Driver/Inc;../../..\ThirdParty\STM32Cube_FW_H7\Drivers/BSP/STM32H750B-Discovery;../../..\ThirdParty\STM32Cube_FW_H7\Drivers/BSP/Components;../../../../../Utilities;../../../../../Utilities/Fonts;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User
    ../../Source/: fmc.c main.c memory_msp.c mmc.c qspi.c stm32h7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../../Source/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../ThirdParty/STM32Cube_FW_H7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c
software components: CMSIS:CORE 5.1.1
