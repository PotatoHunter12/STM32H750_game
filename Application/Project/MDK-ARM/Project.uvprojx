# Keil uVision project Project.uvprojx, settings and files
target STM32H750-Discovery (6140001::V6.14.1::ARMCLANG)
  device: STM32H750ZBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: EmbeddedWizard-STM32H750-Discovery +hex
  c flags: Optim=3 OneElfS=1 v6Lang=4 wLevel=3
  c define: APPLICATION_ADDRESS=0x90000000U STM32H750xx USE_STM32H750B_DK EW_USE_OPERATING_SYSTEM=1
  c include: ../Inc;..\..\..\ThirdParty\STM32Cube_FW_H7/Drivers/CMSIS/Device/ST/STM32H7xx/Include;..\..\..\ThirdParty\STM32Cube_FW_H7/Drivers/STM32H7xx_HAL_Driver/Inc;..\..\..\ThirdParty\STM32Cube_FW_H7/Drivers/BSP/STM32H750B-DK;..\..\..\ThirdParty\STM32Cube_FW_H7/Drivers/BSP/Components;..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers/CMSIS/Include;..\..\..\TargetSpecific\Drivers;..\..\..\TargetSpecific;..\..\GeneratedCode;..\..\Source;..\..\..\ThirdParty\STM32Cube_FW_H7\MiddleWares\Third_Party\FreeRTOS\Source\include;..\..\..\ThirdParty\STM32Cube_FW_H7\MiddleWares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\ThirdParty\STM32Cube_FW_H7\MiddleWares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM7\r0p1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\STM32H750B-DK.sct
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32H750B-DK
    ../../../ThirdParty/STM32Cube_FW_H7/Drivers/BSP/STM32H750B-DK/: stm32h750b_discovery.c stm32h750b_discovery_ts.c stm32h750b_discovery_bus.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../ThirdParty/STM32Cube_FW_H7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_flash.c stm32h7xx_hal_i2c.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_ll_fmc.c stm32h7xx_hal_cortex.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_dma.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_exti.c stm32h7xx_hal_uart_ex.c
  group EmWi/TargetSpecific
    ../../../TargetSpecific/: ew_bsp_graphics.c ew_bsp_clock.c ew_bsp_display.c ew_bsp_event.c ew_bsp_inout.c ew_bsp_console.c ew_bsp_os.c ew_bsp_system.c ew_bsp_touch.c stm32h7xx_it.c system_stm32h7xx.c
    ../../../TargetSpecific/Drivers/: ft5336.c ft5336_reg.c
  group EmWi/Application
    ./: startup_stm32h750xx.s
    ../../Source/: main.c DeviceDriver.c ewmain.c ewconfig.h
  group FreeRTOS
    ../../../ThirdParty/STM32Cube_FW_H7/MiddleWares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../ThirdParty/STM32Cube_FW_H7/MiddleWares/Third_Party/FreeRTOS/Source/: timers.c tasks.c queue.c list.c
    ../../../ThirdParty/STM32Cube_FW_H7/MiddleWares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../ThirdParty/STM32Cube_FW_H7/MiddleWares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1/: port.c
software components: Graphics:Embedded Wizard:New Project... 1.0.0
